# Repository hide4096/TadpoleEx

File README.md:

# TadpoleEx
第18回全日本学生室内飛行ロボットコンテスト自動操縦部門に出場した機体のプログラムと回路図

## KiCad design PCB/Fc_stm32.kicad_pcb

Parts:
C1, C4, C5, C6, C8, C9, C13, C14: 0.1μ; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C12: 2.2μ; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3: 0.33μ; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7, C10: 10μ; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C11: 0.47μ; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: POWER; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
IC1: ICM-20608-G; IAM20680HP; Mouser Part Number 410-ICM-20608-G
J1: USB; HRS_ZX62R-B-5P(30)
J2: CH1; PinHeader_1x03_P2.54mm_Vertical
J3: CH2; PinHeader_1x03_P2.54mm_Vertical
J4: LED; PinHeader_1x02_P1.27mm_Vertical
J5: CH3; PinHeader_1x03_P2.54mm_Vertical
J6: CH4; PinHeader_1x03_P2.54mm_Vertical
J7: CH5; PinHeader_1x03_P2.54mm_Vertical
J8: SBUS; PinHeader_1x03_P2.54mm_Vertical
J9: ToF; PinHeader_1x04_P1.27mm_Vertical
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9: BSS138; SOT-23
R1, R3, R4, R5, R6, R7, R8, R11, R12, R13, R14, R15, R16: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9: 30; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10: 47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: EN; SKRPABE010
U1: NJM2844; SOT-89-5_Handsoldering
U2: CH340K; SSOP-10_3.9x4.9mm_P1.00mm
U3: LPS25HB; ST_HLGA-10_2.5x2.5mm_P0.6mm_LayoutBorder3x2y
U4: ESP32-WROOM-32U

Connections:
+3V3: C1.2, C2.1, C6.2, C7.2, C8.2, C9.1, C10.1, C12.1, C13.1, C14.1, IC1.1 (VDDIO), IC1.16 (VDD), J4.1, J9.1, Q3.1 (G), Q4.1 (G), Q5.1 (G), Q7.1 (G), Q8.1 (G), Q9.1 (G), R1.2, R2.2, R3.1, R5.1, R7.1, R11.1, R13.1, R15.1, U1.4 (VOUT), U2.7 (VCC), U2.10 (V3), U3.1 (VDDio), U3.10 (VDD), U4.2 (VDD)
+5V: C3.1, C5.2, J1.1, J2.2, J3.2, J5.2, J6.2, J7.2, J8.2, R4.1, R6.1, R8.1, R12.1, R14.1, R16.1, U1.1 (CONTROL), U1.5 (VIN)
BOOT: Q2.3 (D), U4.25 (IO0)
CH1: Q3.2 (S), R3.2, U4.12 (IO27)
CH2: Q4.2 (S), R5.2, U4.11 (IO26)
CH3: Q5.2 (S), R7.2, U4.10 (IO25)
CH4: Q7.2 (S), R11.2, U4.9 (IO33)
CH5: Q8.2 (S), R13.2, U4.8 (IO32)
CLK_ALT: U3.2 (SCL/SCLK), U4.13 (IO14)
CLK_IMU: IC1.2 (SCL/SCLK), U4.30 (IO18)
CS_ALT: U3.6 (~CS), U4.23 (IO15)
CS_IMU: IC1.5 (CS), U4.29 (IO5)
EN: C4.1, Q1.3 (D), R1.1, SW1.1, U4.3 (EN)
ESP_RX: U2.8 (TXD), U4.34 (RXD0/IO3)
ESP_TX: U2.9 (RXD), U4.35 (TXD0/IO1)
GND: C1.1, C2.2, C3.2, C4.2, C5.1, C6.1, C7.1, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, D1.1 (K), IC1.8 (FSYNC), IC1.9 (RESV_2), IC1.10 (RESV_3), IC1.11 (RESV_4), IC1.12 (RESV_5), IC1.13 (GND), IC1.15 (RESV_6), J1.5, J2.1, J3.1, J5.1, J6.1, J7.1, J8.1, J9.2, Q6.2 (S), R10.2, SW1.2, U1.2 (GND), U2.3 (GND), U3.3 (GND), U3.8 (GND), U3.9 (GND), U4.1 (GND), U4.15 (GND), U4.38 (GND), U4.39 (GND)
MISO_ALT: U3.5 (SA0/MISO), U4.14 (IO12)
MISO_IMU: IC1.4 (AD0/SDO), U4.31 (IO19)
MOSI_ALT: U3.4 (SDA/MOSI), U4.16 (IO13)
MOSI_IMU: IC1.3 (SDA/SDI), U4.37 (IO23)
unnamed: C11.1, IC1.14 (REGOUT)
unnamed: D1.2 (A), R2.1
unnamed: J1.2, U2.2 (UD-)
unnamed: J1.3, U2.1 (UD+)
unnamed: J2.3, Q3.3 (D), R4.2
unnamed: J3.3, Q4.3 (D), R6.2
unnamed: J4.2, Q6.3 (D)
unnamed: J5.3, Q5.3 (D), R8.2
unnamed: J6.3, Q7.3 (D), R12.2
unnamed: J7.3, Q8.3 (D), R14.2
unnamed: J8.3, Q9.3 (D), R16.2
unnamed: Q1.1 (G), Q2.2 (S), U2.4 (~RTS)
unnamed: Q1.2 (S), Q2.1 (G), U2.6 (~DTR)
unnamed: Q6.1 (G), R9.2, R10.1
unnamed: R9.1, U4.26 (IO4)
RX_SBUS: Q9.2 (S), R15.2, U4.27 (IO16)
SCL_ToF: J9.3, U4.36 (IO22)
SDA_ToF: J9.4, U4.33 (IO21)

Notes on the sheet:
ToF
ESP32
CH1～CH5は 3.3V->5V RX_SBUSは 5V->3.3V
I/O
Power Supply
IMU
Altitude Sensor
UART

Board: 2 copper layers, 36.0 x 40.0 mm, 55 parts (27 on the bottom side), 38 nets.

## Commit log

2022-08-22 [update]IMU,大気圧センサのドライバ書いた
2022-08-27 [update]サーボ制御をマルチスレッド化
2022-08-27 [update]UDP通信追加
2022-08-28 [fix]フリーズを修正
2022-08-28 [update]自動水平旋回を実装
2022-08-28 [fix]放送内容を変更
2022-08-28 [update]ログで吐く情報を追加
2022-08-29 [update]角速度を指定して旋回できるようにした
2022-08-30 [update]ToF追加
2022-09-02 [add]基板データ追加
2022-09-09 [update]add a AutoPilot selector
2022-09-09 [update]add IGain
2022-09-09 [fix]THR fix
2022-09-10 [update]Adjust PID Gain and altitude LPF Gain
2022-09-15 [fix] 着陸誘導方式を変更
2022-09-18 [update]自動操縦動画提出版
2022-09-21 [update]自動旋回のゲインを調整
2022-09-21 [update]全ミッション実装
2022-09-21 [fix]ヨーのアレを修正
2022-09-22 [update]ゲインを調整
2022-09-22 [updare]ゲインを調整
2022-09-22 [final]ゲインを調整
2022-09-24 [last]ゲイン調整
2022-09-25 [fix]WiFiAPをスマホのテザリングに変更
2022-09-27 [final]決勝出場
2022-09-27 [add]公開用に書き換え
2022-09-27 Create LICENSE
2022-10-28 [add]README書いた
2022-10-28 [fix]ライセンスを明記
2022-10-28 [add]全部出す
2022-12-09 [add]CADデータ追加
2022-12-09 [add]gitignode書いた
2022-12-09 [fix]キャッシュを削除
2022-12-09 [fix]キャッシュ削除
2023-09-21 [fix]ドライバ足した
2023-09-21 [fix]ドライバ動いた
2023-09-21 [fix]ドライバ修正
2023-09-21 [fix]高度修正
